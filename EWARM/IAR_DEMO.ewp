# IAR project IAR_DEMO.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\FWLIB\inc; ..\MODBUS\include; ..\MODBUS\functions; ..\MODBUS\rtu; ..\FWLIB\src; ..\CMSIS; ..\PORT; ..\USER\BSP\inc; ..\USER\BSP\src; ..\USER\APP
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IAR_DEMO.hex
  ILINK.IlinkOutputFile: IAR_DEMO.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: ..\CMSIS; ..\PORT; ..\MODBUS\functions; ..\MODBUS\include; ..\MODBUS\rtu; ..\USER\APP; ..\FWLIB\inc; ..\FWLIB\src; ..\USER\BSP\src
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: IAR_DEMO.srec
  group CMSIS
    ../CMSIS/: startup_stm32f10x_hd.s system_stm32f10x.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Modbus-Slave/Modbus
    ../MODBUS/: mb.c
    ../MODBUS/rtu/: mbcrc.c mbrtu.c
    ../MODBUS/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Modbus-Slave/Port
    ../PORT/: port.c portevent.c portserial.c porttimer.c user_mb_app.c
  group USER/App
    ../USER/APP/: main.c stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group USER/Bsp
    ../USER/BSP/src/: dma.c dma.h GPIO.C Timers.c USART.C usart1.c
